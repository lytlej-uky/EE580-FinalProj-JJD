# Keil uVision project PA6LCD.uvprojx, settings and files
target PA6 (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: ST7735
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: startup.s PLL.c ST7735.c fixed.c PA6.c ADCCode.c HC05.c UART.c
software components: CMSIS:CORE 5.6.0
